# Keil uVision project zr356x_dev.uvproj, settings and files
target zr356x_dev (6160000::V6.16::ARMCLANG)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: zr356x_dev +hex
  AfterMake: fromelf.exe --bin -o "$L..\@L.bin" "#L"
  AfterMake: fromelf.exe --text -a -c -o "$L..\@L.txt" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CUSTOMIZE_CFG,DEBUG_PRINTF_OPEN
  c misc: -mfloat-abi=soft -Wno-extra-semi-stmt -Wno-declaration-after-statement -Wno-padded  -Wno-covered-switch-default -Wno-cast-align -Wno-missing-variable-declarations -Wno-switch-enum -Wno-date-time
  c include: ..\app\inc;..\common\inc;..\lib\inc;..\policy\inc;..\common\inc;..\core\inc;..\system\inc;..\lib\inc;..\pd\inc;..\lenevo_sink\inc;..\User\Application_Layer;..\User\Business_Layer;..\User\Function_Module_Layer;..\User\Hardware_Layer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group core
    ../core/src/: startup_CMSDK_CM0.s
  group project
    ./: main.c serial.c user_pd_policy.c
  group app
    ../app/src/: SW356x_v1.6.5.lib
  group lenevo_sink
    ../lenevo_sink/src/: pd_pe_power_swap.c pd_pe_sink.c pd_policy_engine.c sink_policy.c soft_timer.c state_machine.c
  group User/Application_Layer
    ../User/Application_Layer/: app_abnormal_protection.c app_fast_charge.c app_sys_ctl.c
  group User/Business_Layer
    ../User/Business_Layer/: busi_i2c_policy.c busi_share_memory.c busi_port_detection.c busi_base_fast_charge_func.c
  group User/Function_Module_Layer
    ../User/Function_Module_Layer/: func_i2c_api.c func_hardware_api.c sw3566_lib.c func_power_alloc.c
  group User/Hardware_Layer
    ../User/Hardware_Layer/: base_timer_driver.c device_driver.c gpio_config.c i2c_master_driver.c i2c_slave_driver.c i2cm_async_driver.c ntc_temp_sample.c role_identification.c
