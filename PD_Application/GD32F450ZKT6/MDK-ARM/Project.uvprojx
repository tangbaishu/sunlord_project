# Keil uVision project Project.uvprojx, settings and files
target GD32450Z_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F450
  c include: ..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\GD32F4xx_Firmware_Library\CMSIS;..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\Utilities;..\;..\Soft_Drive;..\Hardware_Driver_Layer;..\Function_Module_Layer;..\Business_Logic_Layer;..\Application_Layer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: main.c gd32f4xx_it.c systick.c
    ../Soft_Drive/: at24cxx.c i2c.c
  group CMSIS
    ../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_EVAL
    ../Utilities/: gd32f450z_eval.c
  group Startup
    ../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Doc
    ../: readme.txt
  group Heardware_Driver_Layer
    ../Hardware_Driver_Layer/OLED/: oled.c oled_check.c
software components: CMSIS:CORE 5.5.0
