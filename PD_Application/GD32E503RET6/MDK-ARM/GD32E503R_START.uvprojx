# Keil uVision project GD32E503R_START.uvprojx, settings and files
target GD32E503R_START (6160000::V6.16::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.2
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_HD,USE_STDPERIPH_DRIVER
  c include: ..\.;..\GD32E50x_Firmware_Library\CMSIS;..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\Utilities;..\Application_Layer;..\Business_Logic_Layer;..\Function_Module_Layer;..\Hardware_Driver_Layer;..\Hardware_Driver_Layer\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../: main.c gd32e50x_it.c systick.c
  group CMSIS
    ../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group GD32E50x_START
    ../Utilities/: gd32e503r_start.c
  group Startup
    ../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
  group Doc
    ../: readme.txt
  group Function_Module_Layer
    ../Function_Module_Layer/: LED_Function.c PD_Function.c
  group Hardware_Driver_Layer
    ../Hardware_Driver_Layer/OLED/: oled.c oled_check.c
    ../Hardware_Driver_Layer/IIC_Driver/: software_iic_driver.c iic_api.c
    ../Hardware_Driver_Layer/: LED_Driver.c
  group Hardware_Driver_Layer/BSP
    ../Hardware_Driver_Layer/BSP/PD_Protocol/: sw6233_driver.c
software components: CMSIS:CORE 5.1.1
