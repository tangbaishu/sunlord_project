# Keil uVision project zr356x_dev.uvprojx, settings and files
target zr356x_dev (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: zr356x_dev +hex
  AfterMake: fromelf.exe --bin -o "$L..\@L.bin" "#L"
  AfterMake: fromelf.exe --text -a -c -o "$L..\@L.txt" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CUSTOMIZE_CFG
  c misc: -mfloat-abi=soft -Wno-extra-semi-stmt -Wno-declaration-after-statement -Wno-padded  -Wno-covered-switch-default -Wno-cast-align -Wno-missing-variable-declarations -Wno-switch-enum -Wno-date-time
  c include: ..\app\inc;..\common\inc;..\lib\inc;..\policy\inc;..\common\inc;..\core\inc;..\system\inc;..\lib\inc;..\pd\inc;..\lenevo_sink\inc;..\User\Hardware_Layer;..\User\Function_Module_Layer;..\User\Business_Layer;..\User\Application_Layer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group core
    ../core/src/: startup_CMSDK_CM0.s
  group project
    ./: main.c serial.c user_pd_policy.c
  group app
    ../app/src/: SW356x_v1.6.5.lib
  group lenevo_sink
    ../lenevo_sink/src/: pd_pe_power_swap.c pd_pe_sink.c pd_policy_engine.c sink_policy.c soft_timer.c state_machine.c
  group User/Hardware_Layer
    ../User/Hardware_Layer/: i2c_master_driver.c uart_driver.c base_time_driver.c
    ../User/Hardware_Layer/LED_Driver/: led_driver.c
  group User/Hardware_Layer/OLED
    ../User/Hardware_Layer/OLED/: oled.c oled_check.c
software components: CMSIS:CORE 5.5.0
